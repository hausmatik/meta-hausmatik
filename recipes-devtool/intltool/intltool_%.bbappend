DEPENDS_class-native_append = " gettext-native"
