include recipes-core/images/rpi-hwup-image.bb

IMAGE_INSTALL += "packagegroup-base"
